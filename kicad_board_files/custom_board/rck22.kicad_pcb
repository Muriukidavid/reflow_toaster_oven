# Repository Muriukidavid/reflow_toaster_oven

File README.md:

This is a reflow oven controller based on tinyK22 board with NXP K22P121M120SF7RM MCU.

The goal is to use the board on a breadboard for developing the firmware and design a custom board 

### Prototype Schematic

### Bread Board Prototype

### Custom Board Schematic
<!-- -->

### Custom Board Top View 

A preview of the ongoing Custom board PCB design

A 3D preview of the current design

### BOM
<a href="https://htmlpreview.github.io/?https://github.com/Muriukidavid/reflow_toaster_oven/blob/master/kicad_board_files/custom_board/bom/ibom.html" rel="BOM">

## KiCad design kicad_board_files/custom_board/rck22.kicad_pcb

Parts:
C1, C2, C5, C6, C14, C20: 10uF/6.3V/±20%/X7R/0805; C_0805_2012Metric; Mfr. # GRM21BR70J106KA73L; LCSC # C162423
C3, C4, C9, C10, C11, C12, C13, C15, C16, C17, C18: 100nF/50V/0603; C_0603_1608Metric; Mfr. # GRM188R71H104KA93D; LCSC # C77055
C7: 100nF/16V/X7R/0402; C_0402_1005Metric; Mfr. # GCM155R71C104KA55D; LCSC # C85857
C8: 2.2uF/6.3V/±10%/0603; C_0603_1608Metric; Mfr. # GCM188R70J225KE22D; LCSC # C126582
C19: 10nF/50V/X7R/0603; C_0603_1608Metric; Mfr. # GRM188R71H103JA01D; LCSC # C77388
D1: PMEG2005CT,215; SOT-23; Mfr. # PMEG2005CT,215; LCSC # C282562
D2: NUP2105L; SOT-23; Mfr. # NUP2105LT1G; LCSC # C14486
D3: SP0503BAHT; SOT-143; Mfr. # SP0503BAHTG; LCSC # C7074
D4: GREEN LED; LED_0603_1608Metric; Mfr. # ORH-G36G; LCSC # C205443
D5: RED LED; LED_0603_1608Metric; Mfr. # ORH-B36G; LCSC # C193191
FB1: 330Ohm@100MHz; L_0805_2012Metric; Mfr. # MPZ2012S331AT000; LCSC # C76819
FB2, FB3: bead; L_0603_1608Metric; Mfr. # BLM18PG471SN1D; LCSC # C97853
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.5mm_Pad_Via
IC1: PEC11L-4115F-S0020; PEC11L4115FS0020; Mfr. # PEC11L-4115F-S0020; LCSC # C143799
J1: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical_SMD; Mfr. # 20021221-00010C4LF; LCSC # C180221
J2: USB_OTG; USB_Micro-B_Molex_47346-0001; Mfr. # 47346-0001; LCSC # C132560
J3: PCC-SMP-K
J4: 5V_DC_IN; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal; Mfr. # S2B-PH-K(LF)(SN); LCSC # C265016
J5: header; TerminalBlock_Dinkle_DT-55-B01X-02_P10.00mm
J6, J7, J8: SSR; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal; Mfr. # DB301V-5.0-2P; LCSC # C395882
J9, J10: Conn_01x02; PinSocket_2x01_P2.54mm_Vertical; Mfr. # C49661; LCSC # C49661
JP1: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: karibe_logo
Q1, Q2, Q3: BSS138; SOT-23; Mfr. # BSS138; LCSC # C52895
R1, R8, R9, R10, R11, R12, R13, R15, R16, R17: 10k/0.125W/±1%/0603; R_0603_1608Metric; Mfr. # MR06X1002FTL; LCSC # C304415
R2, R7, R14: 100; R_0603_1608Metric; Mfr. # RC0603FR-07100RL; LCSC # C105588
R3, R4: 33; R_0402_1005Metric; Mfr. # RC0402FR-0733RL; LCSC # C138002
R5: 16.9; R_0603_1608Metric; Mfr. # RCT0316R9FLF; LCSC # C177850
R6: 23.2; R_0603_1608Metric; Mfr. # AC0603FR-0723R2L; LCSC # C227725
R18: 680/±1%/0.1W/0402; R_0402_1005Metric; Mfr. # RK73H1ETTP6800F; LCSC # C159998
SD1: TF-01A; TF01A; Manufacturer_Part_Number TF-01A
SW1, SW2, SW3: PTS810; SW_SPST_PTS810; Mfr. # PTS810SJG250SMTRLFS; LCSC # C221895
TP1, TP3: 5003; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Mfr. # 5003; LCSC # C238124
TP2: 5001; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Mfr. # 5001; LCSC # C238122
TP4: 5002; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; Mfr. # 5002; LCSC # C238123
U1, U5: XC6220B331MR; SOT-23-5; Mfr. # XC6220B331MR-G; LCSC # C86534
U2: MK22FN512VLH12; LQFP-64_10x10mm_P0.5mm; Mfr. # MK22FN512VLH12
U3: MAX31855KASA+T; SOIC-8_3.9x4.9mm_P1.27mm; Mfr. # MAX31855KASA+T; LCSC # C52028
U4: N1616LCD_Shield; Mfr. # C27438; LCSC # C27438
Y1: 8Mhz; Resonator_SMD_muRata_CSTxExxV-3Pin_3.0x1.1mm; Mfr. # CSTCE8M00G55A-R0; LCSC # C91587
Y2: 32.768Khz; Crystal_SMD_2012-2Pin_2.0x1.2mm; Mfr. # SC-20S; LCSC # C97607

Connections:
3v3_SD: C7.1, C20.1, SD1.4 (VDD), U5.5 (VOUT)
+3V3: C6.1, C9.1, C10.1, C11.1, C13.1, J1.1, J6.1, J7.1, J8.1, JP1.2 (B), R1.1, R5.1, R6.1, R9.1, R10.1, R11.1, R12.1, R18.1, TP4.1, U1.5 (VOUT), U2.3 (VDD), U2.13 (VDDA), U2.14 (VREFH), U2.21 (VBAT), U2.30 (VDD), U2.48 (VDD), U3.4 (VCC), U4.7 (3V3)
+5V: D1.3 (A), D3.4 (K), J2.1 (VBUS)
+5VP: C14.1, D1.1 (A), J4.1
/D+: D3.2 (K), J2.3 (D+), R3.2
/D-: D3.3 (K), J2.2 (D-), R4.1
/DN: R4.2, U2.6 (USB0_DM)
/DP: R3.1, U2.5 (USB0_DP)
A: IC1.A1, R16.1
B: IC1.B1, R17.1
ENC_A: C18.1, R16.2, U2.40 (PTB17)
ENC_B: C17.2, R17.2, U2.41 (PTB18)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C17.1, C18.2, C20.2, D2.3 (A), D3.1 (A), D5.1 (K), FB1.2, H1.1, H2.1, H3.1, H4.1, IC1.2, IC1.C1, J1.3, J1.5, J1.9, J2.5 (GND), J3.3 (BAR), J4.2, J9.1, J10.1, R8.2, R13.2, R15.2, SD1.6 (VSS), SD1.MP1, SD1.MP2, SD1.MP3, SD1.MP4, SW1.1, SW2.2, SW3.2, TP2.1, U1.2 (GND), U2.4 (VSS), U2.31 (VSS), U2.47 (VSS), U3.1 (GND), U4.8 (GND), U5.2 (GND), Y1.2
GREEN: D4.1 (K), U2.36 (PTB1)
LCD_CLK: U2.60 (PTD3), U4.2 (CLK)
LCD_CS: U2.58 (PTD1), U4.6 (~CE)
LCD_MOSI: U2.59 (PTD2), U4.3 (MOSI)
LCD_PWM: U2.63 (PTD6), U4.4 (BL)
LCD_RESET: U2.57 (PTD0), U4.5 (RST)
unnamed: C19.1, FB2.1, U3.3 (T+)
unnamed: C19.2, FB3.1, U3.2 (T-)
unnamed: D2.1 (K), FB2.2, J3.1 (T+), J5.1
unnamed: D2.2 (K), FB3.2, J3.2 (T-), J5.2
unnamed: D4.2 (A), R5.2
unnamed: D5.2 (A), R6.2
unnamed: FB1.1, J2.6 (Shield)
unnamed: J6.2, Q2.3 (D)
unnamed: J7.2, Q1.3 (D)
unnamed: J8.2, Q3.3 (D)
unnamed: Q1.1 (G), R2.2
unnamed: Q1.2 (S), R13.1
unnamed: Q2.1 (G), R7.2
unnamed: Q2.2 (S), R8.1
unnamed: Q3.1 (G), R14.2
unnamed: Q3.2 (S), R15.1
unnamed: TP3.1, U2.1 (CLKOUT32K/PTE0)
unnamed: U2.19 (XTAL32), Y2.2
unnamed: U2.20 (EXTAL32), Y2.1
unnamed: U2.32 (PTA18/EXTAL0), Y1.1
unnamed: U2.33 (PTA19/XTAL0), Y1.3
RESET: C3.1, J1.10, R1.2, SW1.2, U2.34 (RESET_b)
SD_CLK: SD1.5 (CLK), U2.50 (PTC5)
SD_CS: SD1.2 (CD/DAT3), U2.44 (PTC1)
SD_MISO: SD1.7 (DAT0), U2.52 (PTC7)
SD_MOSI: SD1.3 (CMD), U2.51 (PTC6)
SD_SW: SD1.CD1, U2.43 (PTC0)
SSR1_PWM: R2.1, U2.56 (PTC11)
SSR2_PWM: R14.1, U2.55 (PTC10)
SSR3_PWM: R7.1, U2.54 (PTC9)
SW: IC1.1, R9.2, U2.42 (PTB19)
SWD_CLK: J1.4, U2.22 (PTA0/SWD_CLK)
SWD_IO: J1.2, R18.2, U2.25 (PTA3/SWD_IO)
SWL: C15.1, J9.2, R10.2, SW2.1, U2.38 (PTB3)
SWO: J1.6, U2.24 (PTA2)
SWR: C16.1, J10.2, R11.2, SW3.1, U2.39 (PTB16)
TEMP_CS: R12.2, U2.61 (PTD4), U3.6 (~CS~)
TEMP_MISO: U2.64 (PTD7), U3.7 (SO)
TEMP_SCK: U2.62 (PTD5), U3.5 (SCK)
UART_RX: J1.8, U2.46 (PTC3)
UART_TX: J1.7, U2.49 (PTC4)
VOUT33: C8.1, JP1.1 (A), U2.7 (VOUT33)
VREF_AGND: C12.2, U2.15 (VREFL), U2.16 (VSSA)
VREF_OUT: C12.1, U2.17 (VREF_OUT)
VREGIN: C1.1, C2.1, C4.1, C5.1, D1.2 (K), TP1.1, U1.1 (VIN), U1.3 (CE), U2.8 (VREGIN), U4.1 (5V), U5.1 (VIN), U5.3 (CE)

Notes on the sheet:
Debug
Encoder
LCD
Power
Thermocouple
USB
Mount Holes
1000mA
SSR
SD Card

Board: 2 copper layers, 95.3 x 72.4 mm, 81 parts (1 on the bottom side), 64 nets.

## KiCad design kicad_board_files/tinyK22_board/reflow_board.kicad_pcb

Board: 2 copper layers, 104.1 x 76.2 mm, 13 parts (0 on the bottom side), 13 nets.

Parts:
C1: 10nF; C_0603_1608Metric
H1, H2, H3: MountingHole; MountingHole_2.5mm
H4: MountingHole_Pad; MountingHole_2.5mm_Pad
J1: Conn_01x05; PinSocket_1x05_P2.54mm_Vertical
J2: Conn_01x02; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J3, J5: Conn_01x21; PinSocket_1x21_P2.54mm_Vertical
J4, J6: Conn_01x08; PinSocket_1x08_P2.54mm_Vertical
R1: 10K; R_0603_1608Metric
SW1: SW_Push; SW_SPST_PTS810

Connections:
+3V3: J4.8, J5.20, R1.2
+5V: J1.2, J4.1, J5.21
GND: C1.2, H4.1, J1.1, J2.2, J3.21, J4.7, J5.1, J5.19, SW1.1
PTB19: C1.1, J5.2, R1.1, SW1.2
PTC8: J2.1, J5.3
PTD0: J1.4, J5.7
PTD1: J1.3, J5.8
PTD3: J1.5, J5.10
PTD4: J4.6, J5.11
PTD5: J4.2, J5.12
PTD6: J4.5, J5.13
PTD7: J4.4, J5.14
PTE1: J4.3, J5.15

## Commit log

2019-05-23 Add initial design for a reflow oven
    Create a KiCad project with schematic and PCB layout for a tinyk22 breakout board
    Add reference documents, datasheets and images
2019-07-28 Add a custom circuit board
    Add a custom circuit board based on NXP K22F MCU on a separate directory
    Put all images in a separate directory for ease of management
    Update the README file
2019-07-28 Remove junk folder
2019-09-07 Add protection to thermocouple input
    Update the thermocouple interface with ferrite beads and filter capacitor
    Add an alternative thermocouple connector other than terminal block
    Add extra SSR lines for the case of multiple heaters
    Replace the 700mA 3.3V regulator with a 1A regulator, and replace its capacitors
    Add 10K series resistors to the rotary encoder ouputs
    Replace buttons with two pin header connectors so as to use momentary switches on the casing
2019-11-24 Tweak the PCB silkscreen, add main UI graphic
    Add some silkscreen text with version number and Logos
    Add a graphic to be loaded from SD card for the main UI before reflow graph
    Tweak the PCB layout and export new images from the 3D viewer
    Update the README
2019-11-24 Add htmlpreview.github.io link to a HTML BOM
2019-12-12 touch up the board
    Re-assign some GPIOs to simplify routing
    Mark SMD components as surface mount in their properties
    Re-arrange power connector and status LEDs
    Replace the SD card component with one readily available at LCSC.com
    Add optional on-board SMD PTS810 buttons
    Change some capacitor footprints from 0402 to 0805 to reduce BOM items
